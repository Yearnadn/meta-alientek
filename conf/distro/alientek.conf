## conf/distro/alientek.conf
```bitbake
require conf/distro/poky.conf

DISTRO_NAME = "alientek"
DISTRO_VERSION = "1.0"

INIT_MANAGER = "systemd"
```
